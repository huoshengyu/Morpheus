Commit message: Added rose_pybullet_interface support. Requires running install script after building container

File: morpheus_teleop/config/test_teapot.urdf (robot description, URDF)
Before this commit: robot test_scene, 1 links, 0 joints
Links:
- link test_link: mass 1 -> 2
